# Keil uVision project AS5050_test.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: AS5050_test +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: .\UserSource;.\Libs\CMSIS;.\Libs\Core;.\Libs\Startup;.\Libs\Drivers\inc;.\Libs\Drivers\src
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group StartUp
    ./Libs/Startup/: startup_stm32f030.s
  group CMSIS
    ./Libs/CMSIS/: stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group UserSources
    ./UserSource/: Init_SPI.c Init_SPI.h main.c stm32f0xx_conf.h EEPROM_24C16.c EEPROM_24C16.h Init_I2C.c Init_I2C.h
  group Drivers
    ./Libs/Drivers/src/: 1wire.c stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c usart.c
